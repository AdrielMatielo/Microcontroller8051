# Keil uVision project Task-4-activation_of_peripherals_with_timer_and_multiplexing.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT80C51RD2 Microchip
  cpu: IRAM(0x00 - 0xFF) XRAM(0x00 - 0x3FF) CLOCK(40000000) MODP2
  output: Task-4-activation_of_peripherals_with_timer_and_multiplexing +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: Task-4-activation_of_peripherals_with_timer_and_multiplexing.asm
