# Keil uVision project T1-E1-Contador_display_7segmentos_pt-r00.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT80C51RD2 Microchip
  cpu: IRAM(0x00 - 0xFF) XRAM(0x00 - 0x3FF) CLOCK(40000000) MODP2
  output: T1-E1-Contador_display_7segmentos_pt-r00 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: T1-E2-Acender_leds_em_serie_r00.asm
